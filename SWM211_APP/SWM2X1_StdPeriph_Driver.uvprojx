# Keil uVision project SWM2X1_StdPeriph_Driver.uvprojx, settings and files
target SWM201 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM201x6 Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SWM2X1_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: CHIP_SWM201
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM2X1_StdPeriph_Driver
  asm define: CHIP_SWM201
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./app/: main.c
    ./APP/: remap.c
  group CSL\StdPD
    ./CSL/SWM2X1_StdPeriph_Driver/: SWM2X1_port.c SWM2X1_gpio.c SWM2X1_exti.c SWM2X1_timr.c SWM2X1_uart.c SWM2X1_adc.c SWM2X1_i2c.c SWM2X1_pwm.c SWM2X1_rtc.c SWM2X1_wdt.c SWM2X1_sleep.c SWM2X1_div.c SWM2X1_cordic.c SWM2X1_spi.c SWM2X1_qei.c SWM2X1_dma.c SWM2X1_can.c SWM201_flash.c SWM211_flash.c SWM2X1_mpu.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM201.c system_SWM211.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM201.s startup_SWM211.s
target SWM211 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM211x8 Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: as above
  output: SWM2X1_APP
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: CHIP_SWM211
  c include: as above
  asm define: CHIP_SWM211
  library: MicroLIB
  memory RVCT4: ROM 0x4000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x2000
